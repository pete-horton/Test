# IAR project Accelerometer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F100xB ST STM32F100xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD_VL
  ICCARM.CCIncludePath2: Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f100xB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Inc
    Inc/: Accelerometer.h core_cm3.h misc.h stm32f10x.h stm32f10x_conf.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_gpio.h stm32f10x_it.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_spi.h stm32f10x_usart.h STM32vldiscovery.h system_stm32f10x.h
  group Src
    Src/: Accelerometer.c core_cm3.c main.c misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_it.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c STM32vldiscovery.c system_stm32f10x.c
  group Startup
    Startup/: startup_stm32f10x_md_vl.s
